<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="793B3646-F6B9-4BBB-87F9-36D0E6F7C22E">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="8E146011-FE55-46B8-BF2B-22BEDBC71F19">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="8DA668F5-4C6C-4D3D-A5FF-6BC4ABECC2A4">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2C3BCD33-350F-4037-8F45-C692EEEA9DA1">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F3FCB2B8-C790-451B-9417-FF3744A50206">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E34CA4BD-DFCB-4D3C-9955-55491FE20707">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="AB722E7D-B002-4CD7-9033-1C449270B9E5">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F68C3BCA-E999-4CCF-BBF5-9C16281995E6">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="19B65F51-F138-4DE3-B6F7-3EC282C7FFF6">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="31951388-2790-43CF-B6D8-DE7AB4E07F9A">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="56ABF5A9-9B52-4D08-A1F0-B8399C7F2307">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="8F13E4B5-BB4E-4585-A5AF-5CC4CC9F18BA">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D7107519-0C6A-4524-A983-77B9A1ACA6FF">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B11D1AD6-6D52-45F6-9D2C-BA59947FFA35">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="18006C9C-89D2-43EB-8DAB-5846AAA9D307">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A9D4FB8A-5B95-4365-8838-EF9B0CD07D4D">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="3D3E385F-C752-450B-ABFE-F7CBB6A83AC9">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C042859E-007F-4882-ABFA-FC46492FF3B9">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BB46B6D5-C0ED-41B5-A9B5-E6181D76C724">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D5F6187D-DADA-486B-A917-C3640FAF0E1C">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9B501678-E38F-4123-883D-9C58F4FCB3DF">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="CD59F1F7-8EB1-4832-9112-1AB76B59A5D6">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7C5C1DAB-D65C-44CE-97E4-6A503E4ABA4F">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A41E147D-849F-4CF0-AC3D-410C761D75B1">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6E56934A-0B9F-4004-89BD-F58613A7AE6B">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="94D63EBA-B01E-4AF9-8467-56D14A1E5536">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D5F3AD97-BF78-48FA-8D4D-0969214677D6">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="D04A2171-97AE-4BAE-B4A2-7E29D2D93041">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9B747544-592F-4887-ADF6-1EACDBD0A999">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D4FFE91C-7E04-4E72-9560-688490F901D5">
      <SHORT-NAME>VehicleProject</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="CCF63A45-5EAB-4DA0-BF42-E95416D0E677">
      <SHORT-NAME>Diagnostics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3145523B-0E8A-4203-930B-9762DDEFCFDB">
      <SHORT-NAME>NM</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2D571229-D35E-4AF7-9E2E-A6EA9F41CA92">
      <SHORT-NAME>TP</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A84294FD-45F0-4771-9CC5-750D2C9D6020">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4A66BD5F-07BE-4562-9A4B-A5120541AE6D">
      <SHORT-NAME>ECU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3AC50133-0AE3-4E51-B6A2-22F5E352F5C5">
      <SHORT-NAME>Gateway</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EB163772-1481-4B9F-90B4-3D2D303078FC">
      <SHORT-NAME>IPDUGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="787E3A23-08AD-4974-B882-58335BA9F8F7">
      <SHORT-NAME>CanFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3B875425-ADA5-430E-A10A-7F1D2194894A">
      <SHORT-NAME>LinFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FB0E66B2-3878-45AE-83F9-B286295345DB">
      <SHORT-NAME>FlexrayFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4EEF1455-8978-4443-95A9-2159CBA02049">
      <SHORT-NAME>PDU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="29C680E1-8A7D-422E-AF93-2B6B6AAA6FDA">
      <SHORT-NAME>ISignal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="23336F28-BECD-489C-A253-BB99AE95D343">
      <SHORT-NAME>DataTransformations</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E60E3226-BC7C-404D-A3BE-B2C267D58DA7">
      <SHORT-NAME>SecureCommunicationPropsSet</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="15759E36-93E4-4947-AFC1-A4352BFA8ED4">
      <SHORT-NAME>SWC</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9882BA27-E489-4E0E-A2A3-FB795D6073FC">
      <SHORT-NAME>DataType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="2EA90AC1-989A-4257-9A66-0236612D900D">
          <SHORT-NAME>Constraint</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B3046470-BF7A-48E8-AD6B-EF42E91D89F2">
          <SHORT-NAME>Semantics</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="63E9571A-66E4-47F7-A02A-D60BDA206E40">
          <SHORT-NAME>Unit</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B42B849C-2CEE-4EA5-969A-76715852A2E5">
      <SHORT-NAME>Constant</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="73820E7C-F53A-4D61-A7DA-5516E064260C">
      <SHORT-NAME>Signal</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>